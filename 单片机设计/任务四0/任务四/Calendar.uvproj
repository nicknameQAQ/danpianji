# Keil uVision project Calendar.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: Calendar +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: ATC24C02.c dalay.c data.c judge.c key.c keypro.c lcd.c main.c cycle.c beep.c serial.c ir.c delay.c
