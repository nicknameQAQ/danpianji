# Keil uVision project 电压表程序.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: 电压表程序 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\..\单片机\15W
  group Source Group 1
    ./: STARTUP.A51 主程序.C
