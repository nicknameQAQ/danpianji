# Keil uVision project Obstacle_Avoid.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89S52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(33000000) MODAT2
  output: bz +hex
  c flags: Optimize=1 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 main.c
