# Keil uVision project 循迹.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: 循迹 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\USER;..\HARDWARE
  group 循迹
    ./: STARTUP.A51 main.c
  group HARDWARE
    ../HARDWARE/: 1602.c pwm.c xunji.c
