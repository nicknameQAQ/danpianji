# Keil uVision project ad_da.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: ad_da +hex
  c flags: Optimize=8 SizeSpeed=1
  group SourceFile
    ./: main.c AD0832.C LCD.C DA0832.C DS18B20.C
  group HeaderileF
    ./: AD0832.H DAC0832.h LCD.H DS18B20.h
