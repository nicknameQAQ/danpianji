# Keil uVision project 自动车码表 显示时间.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: 自动车码表 2 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: 自动车码表 显示时间.c
