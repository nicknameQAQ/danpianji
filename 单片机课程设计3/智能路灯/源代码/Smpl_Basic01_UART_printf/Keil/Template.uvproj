# Keil uVision project Template.uvproj, settings and files
target Template (ARM-ADS)
  device: M453VG6AE Nuvoton
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(50000000) CPUTYPE("Cortex-M4") FPU2
  output: template
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=3
  c include: ..\CMSIS\Include;..\M451Series\Include;..\StdDriver\inc;..\user
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  link misc: --map --first='startup_M451Series.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../M451Series/Source/: system_M451Series.c
    ../M451Series/Source/ARM/: startup_M451Series.s
  group User
    ../: main.c
    ../user/: nuadc.c nuclk.c nugpio.c nuuart.c
  group Library
    ../StdDriver/src/: clk.c eadc.c gpio.c retarget.c sys.c timer.c uart.c
