# Keil uVision project LCD1602-静态显示.uvproj, settings and files
target CEPARK多功能开发学习板/实验箱 (MCS-51)
  device: AT89S52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(33000000) MODAT2
  output: CEPARK +hex
  c flags: Optimize=8 SizeSpeed=1
  group 主项目
    ../Source/: main.c
