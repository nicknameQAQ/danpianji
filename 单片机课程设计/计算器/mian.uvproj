# Keil uVision project mian.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC8A8K64S4A12 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x1FFF) IROM(0-0xFFF8) CLOCK(35000000) MODP2
  output: 科学计算器 +hex
  c flags: Optimize=9 SizeSpeed=1
  group Source Group 1
    ./: LCD1602.c key_drive.c display_driver.c operation.c mian.c insert_edit.c
