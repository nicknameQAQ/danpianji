# Keil uVision project qiangdaqi.uvproj, settings and files
target Target 1 (MCS-51)
  device: 80/87C51BH Intel
  cpu: IRAM(0 - 0x7F)  IROM(0-0xFFF) CLOCK(12000000)
  output: qiangdaqi +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: qiangda.c
