# Keil uVision project 基于单片机设计的数字电子秤.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: 基于单片机设计的数字电子秤 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: 基于单片机设计的数字电子秤.c
